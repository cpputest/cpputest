# IAR project CppUTestTest.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCIncludePath2: ..\..\include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 2
  ILINK.IlinkOutputFile: CppUTestTest.out
  ILINK.IlinkIcfFile: CppUTestTest.icf
  ILINK.IlinkAdditionalLibs: Debug\Exe\cpputest.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.IccLang: 0
  group tests
    ../../tests/CppUTest/: AllTests.cpp
    tests/: iar_argc_argv.c
  group tests/passing
    ../../tests/CppUTest/: AllocationInCFile.c AllocationInCppFile.cpp AllocLetTestFree.c AllocLetTestFreeTest.cpp CheatSheetTest.cpp CommandLineArgumentsTest.cpp CommandLineTestRunnerTest.cpp CompatabilityTests.cpp DummyMemoryLeakDetector.cpp JUnitOutputTest.cpp MemoryLeakDetectorTest.cpp MemoryLeakWarningTest.cpp MemoryOperatorOverloadTest.cpp PluginTest.cpp PreprocessorTest.cpp SetPluginTest.cpp SimpleMutexTest.cpp SimpleStringCacheTest.cpp SimpleStringTest.cpp TeamCityOutputTest.cpp TestFailureNaNTest.cpp TestFailureTest.cpp TestFailureListTest.cpp TestFilterTest.cpp TestHarness_cTest.cpp TestHarness_cTestCFile.c TestInstallerTest.cpp TestMemoryAllocatorTest.cpp TestOutputTest.cpp TestRegistryTest.cpp TestResultTest.cpp TestUTestMacro.cpp TestUTestStringMacro.cpp UtestPlatformTest.cpp UtestTest.cpp
