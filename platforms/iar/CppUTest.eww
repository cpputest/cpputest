<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\CppUTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CppUTestExt.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CppUTestExtTest.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CppUTestTest.ewp</path>
  </project>
  <batchBuild/>
</workspace>


