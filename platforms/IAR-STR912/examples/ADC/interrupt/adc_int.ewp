# IAR project adc_int.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912F ST STR912F
  ICCARM.CCIncludePath2: ..\..\..\include; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ILINK.IlinkOutputFile: adc_int.out
  ILINK.IlinkIcfFile: ..\..\..\linker\STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 91x_it.c main.c
  group source
    $EW_DIR$/ARM/examples/ST/STR91x/STR91xlibrary/source/: 91x_adc.c 91x_gpio.c 91x_lib.c 91x_scu.c 91x_tim.c 91x_vic.c
  group startup
    ../../../startup/: 91x_init.s 91x_vect.s
