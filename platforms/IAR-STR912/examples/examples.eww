<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
  <project>
    <path>$WS_DIR$\ADC\interrupt\adc_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\ADC\polling\adc_pol.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\OPM-PWM\tim.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\GPIO\gpio.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\TIM\PWM\tim_pwm.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\UART\uart.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\CAN\can.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\DMA\dma.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\FMI\fmi.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\MC\mc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\RTC\rtc.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\SSP\ssp.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\WDG\interrupt\wdg_int.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\WDG\polling\wdg_pol.ewp</path>
  </project>
  <project>
    <path>$WS_DIR$\WIU\wiu.ewp</path>
  </project>
  <batchBuild>
    <batchDefinition>
      <name>All</name>
      <member>
        <project>adc_int</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>adc_pol</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>can</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>dma</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>fmi</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>gpio</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>mc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>rtc</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>ssp</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tim</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>tim_pwm</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>uart</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>wdg_int</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>wdg_pol</project>
        <configuration>Debug</configuration>
      </member>
      <member>
        <project>wiu</project>
        <configuration>Debug</configuration>
      </member>
    </batchDefinition>
  </batchBuild>
</workspace>


