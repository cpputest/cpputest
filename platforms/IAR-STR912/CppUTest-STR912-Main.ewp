# IAR project CppUTest-STR912-Main.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912F ST STR912F
  ICCARM.CCDefines: UT_NEW_MACROS_DISABLED; UT_NEW_OVERRIDES_DISABLED
  ICCARM.CCDiagSuppress: Pa050,Pe611
  ICCARM.CCIncludePath2: include; $PROJ_DIR$; ..\..\include
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  OBJCOPY.OOCOutputFile: CppUTest-STR912-Main.srec
  ILINK.IlinkOutputFile: CppUTest-STR912-Main.out
  ILINK.IlinkIcfFile: linker\STR91x_FLASH_CppUTest.icf
  ILINK.IlinkAdditionalLibs: Debug\Exe\IAR-STR912-Lib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: main.cpp
  group include
    ../../include/CppUTest/: CommandLineArguments.h CommandLineTestRunner.h Failure.h JUnitTestOutput.h MemoryLeakDetector.h MemoryLeakWarning.h MemoryLeakWarningPlugin.h PlatformSpecificFunctions.h SimpleString.h TestHarness.h TestHarness_c.h TestOutput.h TestPlugin.h TestRegistry.h TestResult.h TestTestingFixture.h Utest.h UtestMacros.h
  group source
    ../../src/CppUTest/: CommandLineArguments.cpp CommandLineTestRunner.cpp Failure.cpp MemoryLeakDetector.cpp MemoryLeakWarningPlugin.cpp SimpleString.cpp TestHarness_c.cpp TestOutput.cpp TestPlugin.cpp TestRegistry.cpp TestResult.cpp Utest.cpp
    ../../src/CppUTest/Nulls/: NullJUnitTestOutput.cpp
    ../../src/Platforms/Iar/: UtestPlatform.cpp
  group tests
    ../../tests/: CommandLineArgumentsTest.cpp CommandLineTestRunnerTest.cpp FailureTest.cpp NullTestTest.cpp PluginTest.cpp SetPluginTest.cpp SimpleStringTest.cpp TestInstallerTest.cpp TestOutputTest.cpp TestRegistryTest.cpp TestResultTest.cpp UtestTest.cpp
