# IAR project IAR-STR912-Lib.ewp, settings and files
configuration Debug (ARM, debug)
  General.RTConfigPath: $TOOLKIT_DIR$\INC\DLib_Config_Normal.h
  General.OGChipSelectEditMenu: STR912F ST STR912F
  ICCARM.CCIncludePath2: include; $PROJ_DIR$
  ICCARM.CCStdIncludePath: $TOOLKIT_DIR$\INC\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  prebuild: deletelib.bat $EXE_DIR$\*.a
  ILINK.IlinkOutputFile: IAR-STR912-Lib.out
  ILINK.IlinkIcfFile: ..\..\linker\STR91x_FLASH.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ./: 91x_it.c init.c led.c
  group source
    source/: 91x_adc.c 91x_ahbapb.c 91x_can.c 91x_dma.c 91x_emi.c 91x_fmi.c 91x_gpio.c 91x_i2c.c 91x_lib.c 91x_mc.c 91x_rtc.c 91x_scu.c 91x_ssp.c 91x_tim.c 91x_uart.c 91x_vic.c 91x_wdg.c 91x_wiu.c
  group startup
    startup/: 91x_init.s 91x_vect.s
